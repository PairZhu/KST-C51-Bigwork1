# Keil uVision project BigWork1.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Bigwork1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware
  group Source Group 1
    ./: main.c
    ./Hardware/: KeyBoard.c LCD1602.c TimeCounter.c LightGate.c DigitalTube.c
